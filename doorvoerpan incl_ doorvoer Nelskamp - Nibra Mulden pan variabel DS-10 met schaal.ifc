Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: test.ifc
Time: 2011-01-01T11:11:11
Author: Architect
Organization: Building Designer Office
Written by: IFC Engine DLL version 1.03 special version
Made in: example
Authorization: The authorising person

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcFlowTerminal: IFCFLOWTERMINAL, doorvoerpan incl. doorvoer Nelskamp - Nibra Mulden pan variabel DS-10 met schaal
In: Default Building Storey
Description: Onderdeel; Material: Default Material
BCB_Set_ifcflowterminal - WUID: AgAAADLbHdwEAAAA-aQBAAVc6AAAj6cAALtzAAAkpwEAijYAAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAOBDAAAFVpAAAIZSAADAUwAAZ-0AAMySAAAAAJ0UAQAFZgQAAM9KAAC7cwAAPfYAAGe-AAABABAAAQEAAAADAAAAuTwAAAX2tgAAZDAAAManAACjrQAA6dgAAAAA; Hyperlink: http://bibliotheek.bouwconnect.nl/index.html?WUID=AgAAADLbHdwEAAAA-aQBAAVc6AAAj6cAALtzAAAkpwEAijYAAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAOBDAAAFVpAAAIZSAADAUwAAZ-0AAMySAAAAAJ0UAQAFZgQAAM9KAAC7cwAAPfYAAGe-AAABABAAAQEAAAADAAAAuTwAAAX2tgAAZDAAAManAACjrQAA6dgAAAAA; doorvoerelement: dakpandoorvoer met schaal Nelskamp - met schaal; tussenpan: keramische tussenpan Nelskamp - Nibra Mulden pan variabel DS-10; kenmerkende grondstof: terracotta; merk: Nelskamp; serie: Nibra Mulden pan variabel DS-10; type: met schaal
